# Keil uVision project 4.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RD2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: 4
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../2012-11-15 (Aula 4)/: 2.A51

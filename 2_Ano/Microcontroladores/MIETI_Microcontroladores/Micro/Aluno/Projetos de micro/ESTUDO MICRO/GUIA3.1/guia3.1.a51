$NOMOD51
#include<89c51ic2.inc>

	CSEG AT 0H

MAIN:
	MOV R4,#30H
	MOV R1,#80H
	MOV R3,#0A0H
	MOV R2,#20
	
START:
	MOV A,R4
	MOV R0,A
	MOV A,@R0
	MOV R5,A
	RRC A
	JNC PAR

IMPAR:
	MOV A,R3
	MOV R0,A
	MOV A,R5
	MOV @R0,A
	INC R3
	INC R4
	DJNZ R2,START
	JMP FIM
	
PAR:
	MOV A,R5
	MOV @R1,A
	INC R1
	INC R4
	DJNZ R2,START
	
FIM:
	END
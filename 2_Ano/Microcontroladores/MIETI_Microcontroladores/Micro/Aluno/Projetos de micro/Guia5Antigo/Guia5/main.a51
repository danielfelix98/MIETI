$NOMOD51
#include <89c51ic2.inc>

EXTRN CODE (INICIOWAIT)
EXTRN CODE (INICIODISPLAY)
EXTRN CODE (INICIOCHECK)
EXTRN CODE (INICIOREAD)
	
MAIN:
	LCALL INICIOREAD
	MOV A,R0
	MOV R3,A
	LCALL INICIOREAD
	MOV A,R0
	MOV R2,A
	LCALL INICIOREAD
	MOV A,R0
	MOV R1,A
	LCALL INICIOREAD
	LCALL INICIOCHECK
	MOV A,R0
	JNZ TRUE
FALSE:
	MOV R0,#11
	JMP FIM
TRUE:
	MOV R0,#12

FIM:	
	LCALL INICIODISPLAY
	MOV A,#100
	LCALL INICIOWAIT
	MOV R0,#10
	LCALL INICIODISPLAY
	JMP MAIN
END
	
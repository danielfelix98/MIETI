# Keil uVision project guia5.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51IC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: guia5 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.a51 Display.a51 wait.a51 readchar.a51 checkcode.a51 readpass.a51 detectkeys.a51 newpass.a51 wait2.a51 isr.a51 isr2.a51

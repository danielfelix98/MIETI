NAME CONTAR1_0
	
PUBLIC	CONTAR1_0
	
CONTADORCODE	SEGMENT CODE	
RSEG	CONTADORCODE

CONTAR1_0:
	MOV		A,@R0
	INC		SP
	MOV		SP,R0
	MOV		R0,#8
	MOV		R6,#0H
	MOV		R7,#0H
	
LOOP:
	CLR 	c
	RL		A
	JB		ACC.7,TESTE
	INC 	R6
	JMP		COND
	
TESTE:
	INC		R7
	JMP 	COND
	
COND:
	DEC		R0
	CJNE	R0,#0H,LOOP
	DEC		SP
	MOV		R0,SP
	
FIM:
	RET
	
	END
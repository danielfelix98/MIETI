# Keil uVision project ExerciciosTeste.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RD2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: ExerciciosTeste +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Exercicios.a51 CONTAR1_0.a51

$NOMOD51


	CSEG AT 0H
	JMP MAIN
	
MAIN:
	MOV DPTR,#0A000H
	MOV R0,#40H
	MOV R1,#0A0H
	MOV R2,#40
	
CICLO:
	MOVX A,@DPTR
	MOV R3,A
	RLC A
	JNC MENOR
	
MAIOR:
	MOV A,R3
	MOV @R0,A
	INC R0
	INC DPTR
	DJNZ R2,CICLO
	JMP FIM

MENOR:
	MOV A,R3
	MOV @R1,A
	INC R1
	INC DPTR
	DJNZ R2,CICLO
	JMP FIM

FIM:
	END
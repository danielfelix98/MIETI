$NOMOD51
#include <89C51IC2.inc>

	CSEG AT 0H

MAIN: 
MOV R1,#30H
MOV R2,#80H;PAR
MOV R3,#0A0H;IMPAR
MOV R4,#0;CONTADOR
INICIO:
MOV A,@R1

INC R1
MOV B,#2
DIV AB
MOV A,B
CJNE A,#0,IMPAR

PAR:
MOV A,@R1
MOV R0,02H
MOV @R0,A
INC R2
JMP CONTADOR

IMPAR: 
MOV A,@R1
MOV R0,03H
MOV @R0,A
INC R3
CONTADOR:
CJNE R4,#20,INICIO
JMP $
END
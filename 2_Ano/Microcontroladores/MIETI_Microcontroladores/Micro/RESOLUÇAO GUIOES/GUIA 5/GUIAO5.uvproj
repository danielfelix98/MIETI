# Keil uVision project GUIAO5.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RD2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: GUIAO5 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ex1.a51
    ../../../../../Downloads/Guia-5/Guia-5/Guia 5/Ex1/: serie.obj

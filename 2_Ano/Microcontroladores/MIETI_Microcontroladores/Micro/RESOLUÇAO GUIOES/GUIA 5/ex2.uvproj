# Keil uVision project ex2.uvproj, settings and files
target Target 1 (MCS-51)
  device: T89C51RD2 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM (0-0x3FF)  CLOCK(40000000) MODP2
  output: ex2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ex2.a51 serie.obj

#define NLOOPS 20

	CSEG AT 00H
	LJMP MAIN
	
MAIN:
	MOV R1,#30H
	MOV R2,#80H;PAR
	MOV R3,#0A0H;IMPAR
	MOV R4,#0;CONTADOR
LOOP:
	MOV A,@R1
	INC R1
	MOV B,#2
	DIV AB
	MOV A,B
	CJNE A,#0,IMPAR
		
PAR:	
	MOV A,@R1
	mov R0, 02H
	MOV @R0,A
	INC R2
	INC R1
	INC R4
	CJNE R4,#20, LOOP
	JMP FIM
		
IMPAR:
	MOV A,@R1
	MOV R0,03H
	MOV @R0,A
	INC R3
	CJNE R4,#20,LOOP
	JMP FIM
FIM:
		SJMP $
		END
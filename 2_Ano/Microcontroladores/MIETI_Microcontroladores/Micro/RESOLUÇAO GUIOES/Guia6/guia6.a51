#include<89c51ic2.inc>

CSEG AT 00h				
	LJMP MAIN

CSEG AT	2BH
		CPL P2.0
		DJNZ R5,CONF_TIMER2
		JMP DISPLAY
		RETI
DISPLAY:
		MOV DPTR,#NUMEROS
		MOV A,R4
		MOVC A,@A+DPTR
		MOV P1,A
		INC A
		INC R4
		CJNE R4,#LEN,DISPLAY
MAIN:
	MOV R5,#250
	MOV R4,#0
	
CONF_TIMER2:
			MOV T2MOD,#1H
			MOV TH2,#HIGH(-1000)
			MOV TL2,#LOW(-1000)
			MOV RCAP2H,TH2
			MOV RCAP2L,TL2
			SETB TR2
			SETB EA
			SETB EXF2
			JMP $
NUMEROS:
		DB 0CH,0CFH,54H,46H,87H,26H,24H,4FH,04H,07H
LEN EQU $-NUMEROS
	END
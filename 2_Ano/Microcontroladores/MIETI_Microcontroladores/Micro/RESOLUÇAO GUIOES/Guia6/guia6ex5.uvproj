# Keil uVision project guia6ex5.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51IC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: guia6ex5
  c flags: Optimize=8 SizeSpeed=1

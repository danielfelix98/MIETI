EXTRN  CODE (CONFIG_RS232,ENVIAR_RS232,RECEBER_RS232)
		CSEG AT 00H
			CALL CONFIG_RS232
			SJMP MAIN
		CSEG AT 30H
			
TABLE: 
	DB "MICROS 2012"

MAIN:
	MOV DPTR, #TABLE
	MOV R2,#11
	SETB P3.3
	SETB P3.5
	JMP ESCREVER
	
PB1:
	JB P3.3,PB2
	MOV R7,#'1'
	JMP ENVIAR
PB2:
	JB P3.5,PB1
	MOV R7,#'2'
	JMP ENVIAR
	
ESCREVER:
	CLR A
	MOVC A,@A+DPTR
	CALL ENVIAR_RS232
	INC DPTR
	DJNZ R2,ESCREVER
	JMP PB1
ENVIAR:
	MOV A,#0DH
	CALL ENVIAR_RS232
	MOV A,R7
	CALL ENVIAR_RS232
	JMP PB1
	
FIM:
	END
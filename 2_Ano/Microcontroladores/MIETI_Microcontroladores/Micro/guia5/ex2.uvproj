# Keil uVision project ex2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT80C51RD2 Atmel
  cpu: IRAM(0x00 - 0xFF) XRAM(0x00 - 0x3FF) CLOCK(40000000) MODP2
  output: ex2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ex2.a51 serie.obj
